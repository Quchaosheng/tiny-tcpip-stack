# Keil uVision project tcpip.uvprojx, settings and files
target tcpip (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: tcpip +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=5
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\ETHERNET;..\HARDWARE\TIMER;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\RTC;..\HARDWARE\ADC;..\HARDWARE\SRAM;..\HARDWARE\InterTemperate;..\FWLIB\STM32F4x7_ETH_Driver\inc;..\MALLOC;..\USMART;..\LWIP;..\LWIP\arch;..\LWIP\lwip_header;..\LWIP\app\TCP_Client;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip_app\tcp_client_demo;..\LWIP\lwip_app\tcp_server_demo;..\LWIP\lwip_app\udp_demo;..\LWIP\lwip_app\web_server_demo;..\net;..\os;..\net\net;..\plat;..\app;..\FATFS\exfuns;..\FATFS\src;..\HARDWARE\SDIO
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\OBJ\tcpip.sct
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/ETHERNET/: LAN8720.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/InterTemperate/: temperature.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/SDIO/: sdio_sdcard.c sdio_sdcard.h
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_fsmc.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_rng.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_wwdg.c
    ../FWLIB/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group os
    ../os/: os_core.c os_eflags.c os_event.c os_list.c os_mblock.c os_mem.c os_mutex.c os_plat.c os_plat_s.s os_queue.c os_sem.c os_task.c os_timer.c
  group net
    ../net/src/: arp.c dbg.c dns.c ether.c exmsg.c fixq.c icmpv4.c ipaddr.c ipv4.c loop.c mblock.c net.c netapi.c netif.c nlist.c nlocker.c pktbuf.c raw.c sock.c socket.c tcp.c tcp_buf.c tcp_in.c tcp_out.c tcp_state.c timer.c tools.c udp.c
  group plat
    ../plat/: net_plat.c net_plat.h netif_disc.c netif_disc.h netif_pcap.c netif_pcap.h sys_plat.c sys_plat.h
  group app
    ../app/test/: test_net.c app.c test_eflags_0.c test_eflags_1.c test_eflags_2.c test_eflags_3.c test_eflags_4.c test_eflags_5.c test_eflags_6.c test_list_0.c test_mblock_0.c test_mblock_1.c test_mutex_0.c test_mutex_1.c test_queue_0.c test_queue_1.c test_queue_2.c test_queue_3.c test_queue_4.c test_sem_0.c test_sem_1.c test_sem_2.c test_sem_3.c test_sem_4.c test_sem_5.c test_task_0.c test_task_1.c test_task_2.c test_task_3.c
    ../net/net/: net_cfg.h
    ../os/: os_cfg.h
  group tftp
    ../app/tftp/: tftp.c tftp.h tftp_client.c tftp_client.h tftp_server.c tftp_server.h
  group http
    ../app/http/: httpd.c httpd.h
  group ping
    ../app/ping/: ping.c ping.h
  group ntp
    ../app/ntp/: ntp.c ntp.h
  group fatfs
    ../FATFS/src/: diskio.c ff.c ff_system.c
    ../FATFS/src/option/: cc936.c
  group echo
    ../app/echo/: tcp_echo_server.c udp_echo_server.c
target rtos (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: as above
  output: tcpip +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\OBJ\tcpip.sct
software components: Compiler:Event Recorder 1.5.1
